Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2024-01-29T00:32:03
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200210_1400(x64) - Exporter 20.2.12.1 - Alternate UI 20.2.12.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Jan 29 00:32:03 2024 * Host: DESKTOP-13TP49N * Database: C:\Users\andre\AppData\Local\Temp\8f60cd24-d351-4d47-92a9-e92f049f2c17\a1266b88-d455-4e37-8964-71a57c767c6b\ifc * Database version: 5507 * Database creation date: Mon Jan 29 00:32:02 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Jan 29 00:32:02 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Jan 29 00:32:02 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Other - Category: Project Information

# IfcBuildingStorey: Level:Level 1, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SOURCE

# IfcFlowController: 2605FHS-33 Oras Optima Style, 2605FHS-33(2023):2605FHS-33 Oras Optima Style:139103
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - InletConnectionSize: 10 mm; NominalDepth: 168.007 mm; NominalHeight: 197.706 mm; NominalWidth: 50 mm
Type - General - Author: BIMStone; BIMObjectName: 2605FHS-33(2023); ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Water supply fittings for wash basins and troughs; NBSReference: 45-35-70/371; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_96; Uniclass2015Description: Washbasin manual water supply sets; Uniclass2015Reference: Pr_40_20_87_96; Version: 1; VersionDate: 17/01/2024
Type - Green Building Properties - EAN Number: 6414150103544; EN Standard: EN 817; ETIM Class Number: EC011328 Washbasin mixing tap; Sales Package dimensions (LxWxH): 380 x 180 x 74; UNSPSC Class Number: 30181700 Faucets or taps; URL Declaration of Asbestos: http://static.oras.com/doc/asbestos; URL Declaration of Conformity: http://static.oras.com/DoC/2605FHS-33; URL Declaration Of Performance (DOP): http://static.oras.com/doc/DoP; URL Declaration of SCIP: http://static.oras.com/doc/SCIP; URL EcoLabel Declaration: http://static.oras.com/doc/EcoLabel; URL EU Packaging Declaration: http://static.oras.com/doc/packaging; URL REACH: http://static.oras.com/doc/reach
Type - Identity Data - 2D/3D/BIM Files URL: http://static.oras.com/bim/2605FHS-33; 3D View: https://static.oras.com/AR/2605FHS-33; Catalog Drawing URL: http://static.oras.com/catdrw/2605FHS-33; Dimension Drawing URL: http://static.oras.com/dimdrw/2605FHS-33; FDV Document URL: http://www.oras.com/datasheet/2605FHS-33/en/fdv; Group: Sales item; Installation and Maintenance Guide URL: http://static.oras.com/manual/2605FHS-33; Interactive AR View URL: https://static.oras.com/AR/2605FHS-33; Manufacturer: Oras; Market: International;Finland;Norway;Sweden;Denmark; Mobile Product Information URL: http://mpi.oras.com/2605FHS-33; Model: 2605FHS-33 Oras Optima Style; Name_en: 2605FHS-33 Oras Optima Style; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 2605FHS-33; Product Family: null Single-lever;; Product Image URL: http://static.oras.com/image/2605FHS-33; Product URL: http://static.oras.com/2605FHS-33; Technical DataSheet URL: http://www.oras.com/datasheet/2605FHS-33/en; Type Name: 2605FHS-33 Oras Optima Style; Warranty Information URL: http://warranty.oras.com
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Mechanical - Advanced Features: Inner body made of DZR brass; Aerator: Standard aerator;PCA® - constant flow rate regardless of pressure variations; Backflow Prevention EN1717: AA; Connection: Flexible inlet pipes; Connection Size: G3/8; Excluded Items: Without pop-up waste; Installation Type: Deck mounted; Lever Handle: Single operating lever/handle;Pin shape;Hot/Cold symbols; Max. Hot Water Supply: 70 kg/K/s3; Mechanical Parts: 30Cartridge; Mounting Holes: 1 hole; Spout Projection: 133 mm; Spout Type: Fixed spout; Surface treatment: Matt black; Temperature Adjustments: Limitation option for maximum temperature and flow-rate ;Adjustable hot water stop (included, retrofittable);Energy saving variation - cold water in the middle position; Working Pressure: 50 - 1000 kPa
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Matt black; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 2605FHS-33(2023); Features: Washbasin faucet; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 2605FHS-33; Name: 2605FHS-33 Oras Optima Style; ReplacementCost: n/a; Shape: Sculptured; Size: 50x170x200 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Constraints - DefaultElevation: 900 mm; Elevation from Level: 0 mm; Host: Level : Level 1; Level: Level: Level 1; Offset from Host: 0 mm
Dimensions - Area: 0.0526013 m2; Volume: 0.00166551 m3
Identity Data - Mark: 56
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 2605FHS-33(2023): 2605FHS-33 Oras Optima Style; Family and Type: 2605FHS-33(2023): 2605FHS-33 Oras Optima Style; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 2605FHS-33(2023): 2605FHS-33 Oras Optima Style; Type Id: 2605FHS-33(2023): 2605FHS-33 Oras Optima Style; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
